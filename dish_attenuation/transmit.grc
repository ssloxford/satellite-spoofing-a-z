options:
  parameters:
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '144012500'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '47'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.196'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: loop.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: '160000'
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 6e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 6e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '160000'
    interp: '6000000'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: '160000'
    type: fff
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: '1000000'
    center_freq: frequency
    samp_rate: 6e6
    type: fc32
    vga: gain
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}

connections:
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_fm_preemph_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', soapy_hackrf_sink_0, '0']
- [low_pass_filter_1, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_1, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
