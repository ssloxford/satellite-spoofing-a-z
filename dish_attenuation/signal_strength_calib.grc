options:
  parameters:
    author: maraly
    generate_options: qt_gui
    id: signal_strength_calib
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: agc_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,6,1,1
    label0: '"Off"'
    label1: '"Sweep"'
    label2: '"AGC"'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: exp_angle
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,5,1,1
    label: Angle
    type: real
    value: '0'
  states: {}
- name: exp_name
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,4,1,1
    label: Dish name
    type: string
    value: '0'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,2
    lbl: Center frequency
    maxFreqHz: 3.5e9
    minFreqHz: 80e6
    value: '436600000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,5
    label: Input gain
    start: '0'
    step: '1'
    stop: '73'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: show_lpf
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,8,1,1
    initPressed: 'True'
    label: Show LPF
    pressed: '1'
    released: '0'
    type: int
    value: '1'
  states: {}
- name: sig_delta
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,2,1,2
    lbl: Signal offset
    maxFreqHz: '1000000'
    minFreqHz: '100000'
    outputmsgname: sig_delta
    value: '213828'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '15'
    audio_pass: '2000'
    audio_stop: '5000'
    chan_rate: '300000'
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '20000'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-sig_delta)*6.28318530718 /samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: show_lpf
    num_inputs: '2'
    num_outputs: '2'
    output_index: '0'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from gnuradio import qtgui


      class blk(gr.sync_block):
          def __init__(self, strength = 0.01, gain = 0, agc_mode = 0, sweep_delay = 0, sweep_step = 1):
              gr.sync_block.__init__(self,
                  name="AGC",
                  in_sig=[np.float32],
                  out_sig=None)

              self.agc_mode = agc_mode
              self.strength = strength

              self.gain = gain
              self.gain_block = None
              self.control = None

              self.portName = 'messageOutput'
              self.message_port_register_out(pmt.intern(self.portName))

              self.sweep_step = sweep_step
              self.sweep_delay = sweep_delay
              self.stage = 0
              self.counter = 0


          def setup(self, gain_block, control_block):
              self.gain_block = gain_block
              self.gain = self.gain_block.value()
              self.control = control_block

          def work(self, input_items, output_items):
              for i in range(len(input_items)):
                  #Decrease gain
                  if(self.agc_mode == 2):
                      if(input_items[0][i] > 0.8):
                          self.gain -= self.strength
                      if(input_items[0][i] > 0.7):
                          self.gain -= self.strength
                      if(input_items[0][i] < 0.3):
                          self.gain += self.strength
                      if(input_items[0][i] < 0.2):
                          self.gain += self.strength
                      self.gain_block.setValue(int(self.gain))

              if(self.agc_mode == 1):
                  if(input_items[0][-1] > 0.9 or self.gain > 70):
                      self.control.setCurrentIndex(0)
                      self.gain_block.setValue(0)
                  else:
                      self.counter += len(input_items)
                      if (self.counter > self.sweep_delay and self.stage == 0):
                          PMT_msg = pmt.from_bool(True)
                          self.message_port_pub(pmt.intern(self.portName), PMT_msg)
                          self.counter = self.sweep_delay
                          self.stage = 1

                      if (self.counter > self.sweep_delay*1.5 and self.stage == 1):
                          self.counter = 0
                          self.stage = 0

                          self.gain += self.sweep_step
                          self.gain_block.setValue(int(self.gain))
              else:
                  self.counter = 0
                  self.stage = 0

              return len(input_items[0])
    agc_mode: agc_mode
    gain: gain
    strength: '0.01'
    sweep_delay: '100'
    sweep_step: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self, batch_length = 65536):
              gr.decim_block.__init__(self,
                  name="Decimating Max",
                  in_sig=[np.complex64],
                  out_sig=[np.float32],
                  decim = batch_length)

              self.set_relative_rate(1.0/batch_length)
              self.batch_length = batch_length

          def work(self, input_items, output_items):
              n_out_items = len(input_items[0]) // self.batch_length
              for i in range(0, n_out_items):
                  output_items[0][i] = np.max([
                      np.max(np.abs(input_items[0][i*self.batch_length:(i+1)*self.batch_length].real)),
                      np.max(np.abs(input_items[0][i*self.batch_length:(i+1)*self.batch_length].imag))
                  ])
              return len(output_items[0])
    batch_length: '65536'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          def __init__(self, batch_length = 65536):
              gr.decim_block.__init__(self,
                  name="Decimating Averages",
                  in_sig=[np.float32],
                  out_sig=[np.float32,np.float32],
                  decim = batch_length)

              self.set_relative_rate(1.0/batch_length)
              self.batch_length = batch_length

          def work(self, input_items, output_items):
              n_out_items = len(input_items[0]) // self.batch_length
              for i in range(0, n_out_items):
                  output_items[0][i] = np.average(input_items[0][i*self.batch_length:(i+1)*self.batch_length])
                  output_items[1][i] = np.sqrt(
                      (np.average(np.square(input_items[0][i*self.batch_length:(i+1)*self.batch_length])) -
                      output_items[0][i]*output_items[0][i])
                  )
                  pass
              return n_out_items
    batch_length: '65536'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, filename="", fmts=[], columns=[]):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.vector_len = 2
              gr.sync_block.__init__(
                  self,
                  name='Value saver',   # will show up in GRC
                  in_sig=[np.float32] * self.vector_len,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'saveButton'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)

              self.fmts = fmts
              self.columns = columns
              self.last_values = np.zeros(self.vector_len)

              if(filename != ""):
                  self.file = open(filename, "a")

          def handle_msg(self, msg):
              fmt = ("%s\t" + ("\t".join(self.fmts) + ("\t" if 0<len(self.fmts) else 0)) + ("%f\t"*self.vector_len) + "\n")
              self.file.write(fmt % (
                  time.strftime("%Y-%m-%d %H:%M:%S"),
                  *self.columns,
                  *self.last_values)
              )

          def stop(self):
              self.file.close()

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.last_values = [row[-1] for row in input_items]
              return len(input_items[0])
    columns: '[exp_name,freq+sig_delta,exp_angle,gain]'
    filename: '"test.csv"'
    fmts: '["%s","%d","%f","%f"]'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: Distance to clipping (approximate calculation)
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,2
    min: '0'
    name: '"Saturation"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    comment: Amplitude of signal at given frequency
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,2,1,1
    min: '0'
    name: '"Amplitude"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    comment: Amplitude of signal at given frequency
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,3,1,1
    min: '0'
    name: '"RMS"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: 2,0,5,9
    plotfreq: 'False'
    type: complex
  states: {}
- name: save_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 0,7,1,1
    label: Save
    msgName: pressed
    type: bool
    value: 'True'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      #Bugfix 1: the control should never be written into self.var. Since this makes it impossible to have two user inputs that are needed in the same calculation
      #Bugfix 2: .getValue() calls .getFrequency() but doesn't return it
      self.freq = self._freq_msgdigctl_win.getFrequency()
      self.sig_delta = self._sig_delta_msgdigctl_win.getFrequency()
    section: main_after_init
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: self.epy_block_0.setup(self._gain_win.d_widget.counter ,self._agc_mode_combo_box)
    section: main_after_init
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_null_sink_1, '0']
- [blocks_complex_to_mag_0, '0', epy_block_2, '0']
- [blocks_keep_one_in_n_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_rotator_cc_0, '0', blocks_selector_0, '0']
- [blocks_rotator_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_selector_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']
- [epy_block_0, messageOutput, epy_block_3, saveButton]
- [epy_block_1, '0', epy_block_0, '0']
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_2, '0', qtgui_number_sink_0_0_0, '0']
- [epy_block_2, '1', epy_block_3, '1']
- [epy_block_2, '1', qtgui_number_sink_0_0_0_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_keep_one_in_n_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_selector_0, '1']
- [save_button, pressed, epy_block_3, saveButton]
- [soapy_plutosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [soapy_plutosdr_source_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
