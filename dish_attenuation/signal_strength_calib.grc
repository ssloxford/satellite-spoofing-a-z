options:
  parameters:
    author: maraly
    generate_options: qt_gui
    id: signal_strength_calib
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Center frequency
    maxFreqHz: 1e9
    minFreqHz: 100e6
    value: '143800000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Input gain
    start: '0'
    step: '1'
    stop: '73'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: sig_delta
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    lbl: Signal offset
    maxFreqHz: '500000'
    minFreqHz: '100000'
    outputmsgname: sig_delta
    value: '213828'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '262144'
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '262144'
    max_iter: '65536'
    scale: 1000/262144
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1.58/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1.58/1000
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-sig_delta)*6.28318530718 /samp_rate
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: Distance to clipping (approximate calculation)
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    name: '"Saturation"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    comment: Amplitude of signal at given frequency
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '1000'
    min: '0'
    name: '"Amplitude"'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq+sig_delta
    fftsize: '4096'
    plotfreq: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      #Bugfix 1: the control should never be written into self.var. Since this makes it impossible to have two user inputs that are needed in the same calculation
      #Bugfix 2: .getValue() calls .getFrequency() but doesn't return it
      self.freq = self._freq_msgdigctl_win.getFrequency()
      self.sig_delta = self._sig_delta_msgdigctl_win.getFrequency()
    priority: ''
    section: main_after_init
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_abs_xx_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_complex_to_float_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_abs_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_max_xx_0, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_max_xx_0, '1']
- [blocks_rotator_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_complex_to_float_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
