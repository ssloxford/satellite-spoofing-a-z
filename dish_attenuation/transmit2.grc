options:
  parameters:
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '145000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '47'
    value: '16'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1'
    max_dev: 5e3
    quad_rate: if_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '44100'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: transmission2.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: if_samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '500'
    type: fff
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 1e6
    center_freq: frequency
    samp_rate: rf_samp_rate
    type: fc32
    vga: gain
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
